# Keil uVision project Project.uvprojx, settings and files
target STM32F446-BlueCoin (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gesture
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32_BLUECOIN,STM32F446xx,USE_HAL_DRIVER
  c misc: --C99 --no_conditionalize
  c include: ..\Inc;..\..\..\..\..\Drivers\BSP\BlueCoin;..\..\..\..\..\Drivers\BSP\Components\vl53l0x;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/BlueCoin
    ../../../../../Drivers/BSP/BlueCoin/: BlueCoin.c BlueCoin_prox.c
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32f446xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/vl53l0
    ../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Middlewares/GestureDet
    ../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/: ring_buffer.c tof_gestures_DIRSWIPE_1.c tof_gestures_SWIPE_1.c tof_gestures_TAP_1.c tof_motion.c
software components: CMSIS:CORE 5.0.0
